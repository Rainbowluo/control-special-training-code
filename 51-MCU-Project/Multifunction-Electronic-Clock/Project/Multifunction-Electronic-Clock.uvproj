# Keil uVision project Multifunction-Electronic-Clock.uvproj, settings and files
target Multifunction Electronic Clock (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Multifunction-Electronic-Clock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Lib;..\Hardware\digital_tube
  group User
    ./: STARTUP.A51
    ../User/: main.c timer.c uart.c
  group Lib
    ../Lib/: delay.c
  group Hardware
    ../Hardware/digital_tube/: digital_tube.c
  group Doc
    ../Doc/: readme.txt
